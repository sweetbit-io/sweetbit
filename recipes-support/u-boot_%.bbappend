MENDER_UBOOT_AUTO_CONFIGURE = "0"
