# Disable the systemd Mender service
SYSTEMD_AUTO_ENABLE = "disable"
