PACKAGECONFIG = "deprecated readline tools"
