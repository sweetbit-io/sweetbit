INITSCRIPT_PARAMS = "stop 20 0 1 6 ."
